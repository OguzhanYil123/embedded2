## zephyr/sample.yaml
```yaml
sample:
  name: DHT Sensor
tests:
  sample.sensor.dht:
    build_only: true
    platform_allow: nrf52dk_nrf52832
    tags: sensors
```
